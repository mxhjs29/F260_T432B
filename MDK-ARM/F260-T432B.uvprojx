# Keil uVision project F260-T432B.uvprojx, settings and files
target F260-T432B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F260-T432B +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ../Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                       ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                       ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                       ../Drivers/CMSIS/Include;                       ..\Module;                       ..\Math;                       ..\Control;                       ..\GUI;                       ..\GUI\lvgl;                       ..\GUI\lv_drivers;                       ..\GUI\lv_examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Module/: system.c
    ../Src/: main.c gpio.c dma.c i2c.c stm32f4xx_it.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Module
    ../Module/: beep.c LED.c mpu6050.c imu.c Ano_OF.c gcs.c HARDWARE_uart.c HARDWARE_i2c.c speed_estimator.c ZKHD_Link.c server.c motor.c lcd.c lcd_init.c lcd_status.c power.c UWB.c
    ../Control/: Init.c
    ../Src/: status.c
  group Math
    ../Math/: filter.c myMath.c pid.c my_queue.c
  group Control
    ../Control/: control.c height_control.c pos_ctrl.c remote.c SDK.c FollowLine.c program_ctrl.c
software components: CMSIS:CORE 4.3.0
